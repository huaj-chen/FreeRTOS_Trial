# Keil uVision project my_FreeRTOS.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: my_FreeRTOS +hex
  c flags: Optim=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM3;..\User;..\Libraries\CMSIS;..\Libraries\FWlib\inc;..\User\uart;..\User\uart
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Trial
    ../User/uart/: bsp_usart.c
  group User
    ../User/: main.c FreeRTOSConfig.h
    ../Libraries/FWlib/inc/: stm32f10x_it.h
    ../Libraries/FWlib/src/: stm32f10x_it.c
  group FreeRTOS/Source
    ../FreeRTOS/Source/: croutine.c list.c tasks.c timers.c queue.c event_groups.c
  group FreeRTOS/Ports
    ../FreeRTOS/portable/RVDS/ARM_CM3/: port.c
    ../FreeRTOS/portable/MemMang/: heap_2.c
  group StartUp
    ../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../Libraries/CMSIS/: stm32f10x.h core_cm3.c system_stm32f10x.c core_cm3.h system_stm32f10x.h
  group FWlib
    ../Libraries/FWlib/src/: misc.c stm32f10x_usart.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c
